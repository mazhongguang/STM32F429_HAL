# Keil uVision project STM32F429.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\HALLIB\Inc;..\HALLIB\Inc\Legacy;..\MALLOC;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\emwin\Config;..\emwin\inc;..\emwin\App;..\emwin\mytest;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\sdio;..\HARDWARE\KEY;..\HARDWARE\TIM;..\MALLOC;..\FATFS\source;..\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f429xx.s
  group hallib
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_sram.c stm32f4xx_hal_pwr_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group DSP_lib
    ../dsp_lib/ARM/: arm_cortexM4lf_math.lib
  group hardware
    ../HARDWARE/KEY/: KEY.C
    ../HARDWARE/LCD/: ILI9341.C font.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/TIM/: timer.c
    ../HARDWARE/sdio/: sdio_sdcard.c
  group system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group user
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group FATFS
    ../FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group malloc
    ../MALLOC/: MALLOC.C
